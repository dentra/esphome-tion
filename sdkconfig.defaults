## sdkconfig.defaults
```kconfig
CONFIG_BT_ENABLED=y
CONFIG_ESP_COREDUMP_ENABLE_TO_FLASH=y
CONFIG_ESP_COREDUMP_DATA_FORMAT_ELF=y
```
